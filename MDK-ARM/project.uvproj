# Keil uVision project project.uvproj, settings and files
target STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD HSE_VALUE=8000000
  c include: ..\ff11\src;..\driver\include;..\STM32F10x_StdPeriph_Driver\inc;..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\app\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c
  group driver
    ../driver/: usart.c sdcard.c retarget.c
  group library
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group fatfs
    ../ff11/src/: diskio.c ff.c
    ../ff11/src/option/: syscall.c
